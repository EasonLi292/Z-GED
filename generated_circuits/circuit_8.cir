* GraphGPT Generated Circuit 8
* Auto-generated from trained GraphGPT model

.title GraphGPT_Circuit_8

* Input voltage source
Vin 1 0 AC 1.0

* Circuit components
C1 0 2 15.7976pF
R1 0 2 22.877MegOhm
R2 1 2 4.02455MegOhm

* AC Analysis from 1Hz to 100kHz
.ac dec 100 1 100k

* Output
.print ac v(2)

.end
